# IAR project mine.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: hal\include; hal\common; hal\hal_430f149
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: hal\common; hal\include; hal\hal_430f149
  ICC430.CCOptLevel: 3
  group (top)
    app/cc1101tx/: maintx.c
  group hal_430f149
    hal/hal_430f149/: hal_board.c hal_digio.c hal_led.c hal_mcu.c hal_uart.c
  group hal_common
    hal/common/: hal_rf.c hal_spi.c hal_spi_config.c
